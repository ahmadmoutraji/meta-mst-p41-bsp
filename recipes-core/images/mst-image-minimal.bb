SUMMARY = "A small microsensytech image just capable of allowing a device to boot."

LICENSE = "MIT"

require mst-core-image.inc
